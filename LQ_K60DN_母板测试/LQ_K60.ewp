# IAR project LQ_K60.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCIncludePath2: src\Includes; src\User; src\Project_Setting; src\Project_Setting\Startup; src\Project_Setting\Linker_Files; src\Libs
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LQ_K60.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: src\Project_Setting\Linker_Files\Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group Includes
    src/Includes/: ADC.h common.h DMA.h FTM.h GPIO.h GPIO_Cfg.h I2C.h Lptmr.h LQ12864.h LQKEY.h LQLED.h PIT.h PLL.h UART.h vectors.h wdog.h
  group Libs
    src/Libs/: MK60N512VMD100.h
  group Project_Setting/Linker_Files
    src/Project_Setting/Linker_Files/: Pflash.icf
  group Project_Setting/Startup
    src/Project_Setting/Startup/: crt0.s start.c
  group Sourse
    src/Source/: ADC.c common.c DMA.c FTM.c GPIO.c I2C.c Lptmr.c LQ12864.c LQKEY.c LQLED.c PIT.c PLL.c UART.c vectors.c wdog.c
  group User
    src/User/: include.h LQ9AX.c LQ9AX.h LQIIC6050.c LQMPU6050.h main.c picture.h Serial_oscilloscope.c Serial_oscilloscope.h u_iic.c u_iic.h
  group User/LQMT9V034M
    src/User/: LQMT9V034.c LQMT9V034.h LQMT9V034M.a LQMT9V034M.c LQMT9V034M.h
